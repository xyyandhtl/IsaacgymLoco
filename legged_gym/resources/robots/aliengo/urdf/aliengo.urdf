Commit message: add amp retarget pipeline, reorganize datasets, amp_obs add z_pos

File: legged_gym/resources/robots/aliengo/urdf/aliengo.urdf (robot description, URDF)
Before this commit: robot aliengo, 31 links, 30 joints
Links:
- link imu_link: geometry visual box size=0.001 0.001 0.001
